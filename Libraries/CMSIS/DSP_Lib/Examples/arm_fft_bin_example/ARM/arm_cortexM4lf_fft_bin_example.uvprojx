# Keil uVision project arm_cortexM4lf_fft_bin_example.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm_cortexM4lf_fft_bin_example
  c flags: Optim=3 oTime=1 wLevel=2
  c define: ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: ..\..\..\..\Include;..\..\..\..\..\Device\ARM\ARMCM4\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ../: arm_fft_bin_data.c arm_fft_bin_example_f32.c
  group CMSIS Device
    ../: system_ARMCM4.c
    ./: startup_ARMCM4.s
  group CMSIS DSP_Library
    ../../../../Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
