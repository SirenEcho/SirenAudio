# Keil uVision project Audio-DSP.uvprojx, settings and files
target Audio-DSP (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Audio-DSP +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: ..\inc;..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Utilities\Third_Party\fat_fs\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Utilities\STM32F4-Discovery;..\MDK-ARM;..\..\Libraries\ub_lib;..\..\Libraries\ub_lib\fatfs;..\..\Libraries\ub_lib\fatfs\lo_level_ub;..\..\Libraries\ub_lib\usb_msc_host_lolevel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c headphone.c microphone.c dsp.c
  group STM32F4-Discovery
    ../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_audio_codec.c libPDMFilter_Keil.lib
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_rng.c
    ./../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_dac.c stm32f4xx_exti.c
  group MDK-ARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Usblib
    ../../Libraries/ub_lib/: stm32_ub_fatfs.c stm32_ub_usb_msc_host.c
    ../../Libraries/ub_lib/usb_msc_host_lolevel/: usb_bsp.c usb_core.c usb_hcd.c usb_hcd_int.c usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c usbh_stdreq.c usbh_usr.c
  group Fatfs
    ../../Libraries/ub_lib/fatfs/: diskio.c ff.c
    ../../Libraries/ub_lib/fatfs/lo_level_ub/: stm32_ub_atadrive.c stm32_ub_sdcard.c stm32_ub_usbdisk.c
